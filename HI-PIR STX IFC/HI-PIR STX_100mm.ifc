Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-02-24T10:15:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.2.0.0 - Alternate UI 17.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 24 10:15:31 2017 * Host: DESKTOP-CA24E47 * Database: C:\Users\PC002\AppData\Local\Temp\{56856E7E-CF86-4EAA-BF1B-48DCD68E9BEF}\ifc * Database version: 5507 * Database creation date: Fri Feb 24 10:15:31 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Feb 24 10:15:31 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 24 10:15:31 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 m
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 m
Dimensions - Computation Height: 0 m
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcCurtainWall: Curtain Wall:Curtain Wall, Curtain Wall:Curtain Wall:200770
In: Level 1
Type - Construction(Type) - Automatically Embed: no; Function: Exterior; Join Condition: Not Defined
Type - Horizontal Grid(Type) - Adjust for Mullion Size: no
Type - Identity Data(Type) - Type Name: Curtain Wall
Type - Other(Type) - Category: Walls; Family Name: Curtain Wall
Type - Vertical Grid(Type) - Adjust for Mullion Size: no
Pset_CurtainWallCommon - Reference: Curtain Wall; IsExternal: yes
Constraints - Base Constraint: Level: Level 1; Base is Attached: no; Base Offset: 0 m; Related to Mass: no; Room Bounding: yes; Top is Attached: no; Top Offset: 0 m; Unconnected Height: 8 m
Dimensions - Area: 24 m2; Length: 3 m
Horizontal Grid - Angle: 0 deg; Justification: Beginning; Number: 4; Offset: 0 m; sets with these values: 2
Other - Category: Walls; Family: Curtain Wall: Curtain Wall; Family and Type: Curtain Wall: Curtain Wall; Type: Curtain Wall: Curtain Wall; Type Id: Curtain Wall: Curtain Wall
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing

# IfcPlate: HI-PIR STX 100, HI-PIR STX:100 mm:200771
In: Level 1
Type - ElementType: 100 mm; PredefinedType: CURTAIN_PANEL; Material: Huurre_Panel
Type - Analytical Properties(Type) - Analytic Construction: <None>
Type - Dimensions(Type) - CoreInsulationDepth: 0.1 m; OverallThickness: 0.1 m
Type - Energy Analysis(Type) - R: 4.56; U-Value: 0.21
Type - Identity Data(Type) - OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Name: 100 mm
Type - Materials and Finishes(Type) - Finish: E5001 / Poliéster 25micras / HDX 55 micras / HDS 35 micras / PVDF 35 micras / PET 50 micras; PanelMaterial: Huurre_Panel
Type - Other(Type) - Category: Curtain Panels; Ancho: 1.15 m; Aplicación: Fachadas/divisiones internas; Características Medioambientales: Libre de SVHC Sustancias extremadamente preocupantes de acuerdo con requisitos de REACH. Proceso de fabricación sin liberación de gases tipo HCFCs.; Certificados: Marcado CE, Marca N AENOR; Color de acabado: www.huurreiberica.com/docs/HUURRE-CARTA-COLORES.pdf; Comportamiento frente al fuego: Euroclase B,s1,d0; Densidad nominal del núcleo aislante: 40 kg/m3; Family Name: HI-PIR STX; Ficha técnica del producto: www.huurreiberica.com/index.php/es/paneles-aislantes/hi-stx-fachada-semi-liso; Fijaciones: Tornillos de acero al carbono / inoxidable con arandelas de estanqueidad; Garantía: Hasta 25 años prestaciones funcionales, hasta 35 años para sus recubrimientos; Material cara exterior: Chapa perfilada de acero; Material cara interior: Chapa perfilada de acero; Material de junta: Banda de polietileno de celda cerrada y densidad 33 kg/m3; Material Núcleo Aislante: Espuma PIR HUURRE; Normas de referencia: UNE EN 14509 para paneles, UNE EN 10327 para recubrimiento galvanizado, UNE EN 10169 para recubrimientos orgánicos; Peso: 1.16408; Referencia de producto: HI-PIR STX 100; Suministrador: HUURRE IBÉRICA S.A.; Tipo de junta: Machihembrada; Transmitancia térmica: 0.0217; Web del fabricante: www.huurreiberica.com
Constraints - Level: Level: Level 1
Dimensions - Area: 24 m2; Height: 8 m; Volume: 0.912121 m3; Width: 3 m
Other - Category: Curtain Panels; Family: HI-PIR STX: 100 mm; Family and Type: HI-PIR STX: 100 mm; Host Id: Curtain Wall: Curtain Wall; Type: HI-PIR STX: 100 mm; Type Id: HI-PIR STX: 100 mm
Phasing - Phase Created: New Construction
Pset_PlateCommon - IsExternal: yes; Reference: 100 mm; LoadBearing: yes
